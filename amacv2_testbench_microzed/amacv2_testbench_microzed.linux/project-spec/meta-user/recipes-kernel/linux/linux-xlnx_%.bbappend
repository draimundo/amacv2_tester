SRC_URI += "file://user_2018-06-26-16-28-00.cfg"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

