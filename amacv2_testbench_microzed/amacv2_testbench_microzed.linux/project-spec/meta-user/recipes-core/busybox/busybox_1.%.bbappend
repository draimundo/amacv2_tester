SRC_URI_append = " file://syslog-startup.conf"

FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
